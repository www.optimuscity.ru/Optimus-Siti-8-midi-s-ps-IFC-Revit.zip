Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 8.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 8.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
